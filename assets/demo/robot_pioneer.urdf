Commit message: Added ray sensor to Pioneer robot

File: assets/demo/robot_pioneer.urdf (robot description, URDF)
Before this commit: robot Robot Pioneer, 5 links, 4 joints
Links:
- link base_link: geometry collision cylinder length=0.02 radius=0.19; visual cylinder length=0.06 radius=0.02
