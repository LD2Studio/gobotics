Commit message: Better pygobotics & creating robot scene

File: assets/demo/slider.urdf (robot description, URDF)
Before this commit: robot Slider, 2 links, 1 joints
Links:
- link arm: mass 1 -> 0.1
