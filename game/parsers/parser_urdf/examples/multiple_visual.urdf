Commit message: Add Asset editor

File: game/parsers/parser_urdf/examples/multiple_visual.urdf (robot description, URDF)
Before this commit: robot multiple_visual, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.5 0.5 0.1; collision cylinder length=0.5 radius=0.05
